# Disable ipmbbridged service by default
SYSTEMD_AUTO_ENABLE ?= "disable"
