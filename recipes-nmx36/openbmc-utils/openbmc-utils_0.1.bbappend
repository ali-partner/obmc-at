# Copyright 2021-present Facebook. All Rights Reserved.
FILESEXTRAPATHS:append := "${THISDIR}/files:"
#LOCAL_URI += "file://setup-reboot.sh"
S = "${UNPACKDIR}"
LOCAL_URI += "file://board-utils.sh \
            file://cpld_ver.sh \
            file://cpu_state.sh \
            file://disable_watchdog.sh \
            file://eth0_mac_fixup.sh \
            file://eth0_create_vlan.sh \
            file://fpga_ver.sh \
            file://power-on.sh \
            file://setup_emmc.sh \
            file://sol.sh \
            file://spi_util.sh \
            file://us_console.sh \
            file://diag_i2c.sh \
            file://boot_area.sh \
            file://system_led.sh \
            file://power.sh \
            file://switch_uart.sh \
            file://diag_peci.sh \
            file://Diag_batt.sh \
            file://create_vlan_intf \
            file://detect_AER.sh \
            file://detect_MSR.sh \
            file://dump_AER.sh \
            file://dump_MSR.sh \
            file://version.sh \
            file://sync_date.sh \
            file://create_static_ip \
            file://check_fan.sh \
            file://cpld_update.sh \
            file://diag_wdt_func.sh \
            file://diag_wdt.sh \
            file://reset_mac.sh \
            file://fan_util.sh \
            file://fan_watchdog.sh \
            file://diag_sensors.sh \
            file://switch_cpld.sh \
            file://power_force_ctrl.sh \
            file://phy_update.sh \
            file://diag_asic_voltage.py \
            file://fpga_flash.sh \
            file://boot_util.sh \
            file://diag_flash_info.sh \
            file://diag_fru_eeprom_wp.sh \
            file://diag_rtc.sh \
            file://power_util.sh \
            file://show_version.sh \
            file://diag_fan.sh \
            file://diag_spi.sh \
            file://diag_led.sh \
            file://diag_start_check.sh \
            file://diag_uart.sh \
            file://fwm_util.sh \
            file://diag_platform_func.sh \
            file://diag_psu.sh \
            file://diag_gpio_util.sh \
            file://reset_reason.sh \
            file://diag_bmc_mtd.sh \
            file://get_thermal_sensor.sh \
            file://diag_mgmt_func.sh \
            file://spi_util_gpio.sh \
            file://sp4_flash.sh \
            file://diag_miim.sh \
            file://setup_board.sh \
            file://setup_platform.sh \
            file://init_early.sh \
            file://store_version.sh \
            file://sensor-mon.sh \
            file://temperature_screening.sh \
            file://hal_rawcmd.py \
            file://fw_refresh.sh \
            file://ast-mdio.py \
            file://power_on_config_setup.sh \
            file://gpio_jtag_init.sh \
            file://gpio_utils.sh \
            file://fpga_update.sh \
            file://mac_power_off.sh \
            file://diag_mac_power.sh \
            file://avs_current_monitor.sh \
            file://avs-chip-func.py \
            file://diag_fan_speed_check.sh \
            file://diag_otp_boot.sh \
            file://dump_MSR_reg.sh \
            file://set_product_name.sh \
            file://show_product_name.sh \
            file://i2c_topology_create_AS42-64S-AT.sh \
            file://AS42-64S-AT_board-utils.sh \
            file://setup_ina3221.sh \
           "

OPENBMC_UTILS_FILES += " \
    board-utils.sh \
    cpld_ver.sh \
    cpu_state.sh \
    disable_watchdog.sh \
    eth0_mac_fixup.sh \
    eth0_create_vlan.sh \
    fpga_ver.sh \
    power-on.sh \
    setup_emmc.sh \
    sol.sh \
    spi_util.sh \
    us_console.sh \
    diag_i2c.sh \
    boot_area.sh \
    system_led.sh \
    power.sh \
    switch_uart.sh \
    diag_peci.sh \
    Diag_batt.sh \
    create_vlan_intf \
    detect_AER.sh \
    detect_MSR.sh \
    dump_AER.sh \
    dump_MSR.sh \
    version.sh \
    sync_date.sh \
    create_static_ip \
    check_fan.sh \
    cpld_update.sh \
    diag_wdt_func.sh \
    diag_wdt.sh \
    reset_mac.sh \
    fan_util.sh \
    fan_watchdog.sh \
    diag_sensors.sh \
    switch_cpld.sh \
    power_force_ctrl.sh \
    phy_update.sh \
    diag_asic_voltage.py \
    fpga_flash.sh \
    boot_util.sh \
    diag_flash_info.sh \
    diag_fru_eeprom_wp.sh \
    diag_rtc.sh \
    power_util.sh \
    show_version.sh \
    diag_fan.sh \
    diag_spi.sh \
    diag_led.sh \
    diag_start_check.sh \
    diag_uart.sh \
    fwm_util.sh \
    diag_platform_func.sh \
    diag_psu.sh \
    diag_gpio_util.sh \
    reset_reason.sh \
    diag_bmc_mtd.sh \
    get_thermal_sensor.sh \
    diag_mgmt_func.sh \
    setup_board.sh \
    spi_util_gpio.sh \
    sp4_flash.sh \
    diag_miim.sh \
    setup_platform.sh \
    init_early.sh \
    store_version.sh \
    sensor-mon.sh \
    temperature_screening.sh \
    hal_rawcmd.py \
    fw_refresh.sh \
    ast-mdio.py \
    power_on_config_setup.sh \
    gpio_utils.sh \
    gpio_jtag_init.sh \
    fpga_update.sh \
    mac_power_off.sh \
    diag_mac_power.sh \
    avs_current_monitor.sh \
    avs-chip-func.py \
    diag_fan_speed_check.sh \
    diag_otp_boot.sh \
    dump_MSR_reg.sh \
    set_product_name.sh \
    show_product_name.sh \
    i2c_topology_create_AS42-64S-AT.sh \
    AS42-64S-AT_board-utils.sh \
    setup_ina3221.sh \
    "

