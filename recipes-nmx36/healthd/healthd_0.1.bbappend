# Copyright 2020-present Facebook. All Rights Reserved.
FILESEXTRAPATHS:append := "${THISDIR}/files:"
S = "${UNPACKDIR}"
LOCAL_URI += " \
    file://healthd-config.json \
    "
