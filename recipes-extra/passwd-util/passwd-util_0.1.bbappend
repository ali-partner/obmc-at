FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
S = "${UNPACKDIR}"
SRC_URI += "file://passwd-util.service \
          "
