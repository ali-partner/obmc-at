
FILES:tzdata-core += " \
    ${datadir}/zoneinfo/Asia/Shanghai \
    "

DEFAULT_TIMEZONE = "Asia/Shanghai"